# Keil uVision project ble_app_multilink_central.uvprojx, settings and files
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ble_app_multilink_central +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER S120_SUPPORT_REQD BOARD_NRF6310 ENABLE_DEBUG_LOG_SUPPORT
  c misc: --c99
  c include: ..;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\..\..\..\..\..\Include\ble;..\..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\..\Include\s120;..\..\..\..\..\..\include\boards;..\..\..\..\..\..\include\sd_common;..\..\..\experimental;..\..\common;..\..\..\..\..\..\Include\gcc;..\..\..\..\..\..\lp
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x27000
  memory RVCT9: RAM 0x20002800 size 0x1800
  group Startup Code
    ../../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
    ../: client_handling.c
    ../../../../../../lp/: delay.c led.c time.c uart.c
  group Services
    ../../../../../../Source/ble/ble_services/: ble_srv_common.c
  group Libraries
    ../../../../../../Source/ble/: ble_debug_assert_handler.c
    ../../common/: softdevice_handler.c conn_mngr.c debug.c
    ../../../../../../Source/simple_uart/: simple_uart.c
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_multilink_central +hex
  c flags: Optim=1 wLevel=2
  c define: as above
  c misc: --c99
  c include: ..;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\..\..\..\..\..\Include\ble;..\..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\..\Include\s120;..\..\..\..\..\..\include\boards;..\..\..\..\..\..\include\sd_common;..\..\..\experimental;..\..\common
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x7000
  memory RVCT9: RAM 0x20002800 size 0x1800
